# Keil uVision project STM32L0_BMA253.uvprojx, settings and files
target STM32L0_BMA253 (ARM-ADS)
  device: STM32L010F4Px STMicroelectronics
  cpu: IRAM(0x20000000-0x200007FF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: STM32L0_BMA253 +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./STM32L0_BMA253/STM32L0_BMA253.bin ./STM32L0_BMA253/STM32L0_BMA253.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,MSI_VALUE=2097000,HSI_VALUE=16000000,LSI_VALUE=37000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32L010x4
  c include: ../Core/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;../user/bma253;../user/common;../user/lpuart;../user/pedometer;../user/print;../user/sflash
  group Application/MDK-ARM
    ./: startup_stm32l010x4.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c lptim.c usart.c rtc.c spi.c stm32l0xx_it.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_ll_gpio.c stm32l0xx_ll_dma.c stm32l0xx_ll_i2c.c stm32l0xx_ll_rcc.c stm32l0xx_ll_utils.c stm32l0xx_ll_exti.c stm32l0xx_ll_lptim.c stm32l0xx_ll_lpuart.c stm32l0xx_ll_rtc.c stm32l0xx_ll_spi.c stm32l0xx_ll_pwr.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group user
    ../user/bma253/: bma253_iic.c bma253.c
    ../user/common/: common.c
    ../user/lpuart/: tiny_sscanf.c tiny_vsnprintf.c utilities.c vcom.c
    ../user/pedometer/: at.c command.c step_process.c
    ../user/print/: print.c
    ../user/sflash/: array_queue.c w25qxx.c write_sflash.c
software components: CMSIS:CORE 4.3.0
